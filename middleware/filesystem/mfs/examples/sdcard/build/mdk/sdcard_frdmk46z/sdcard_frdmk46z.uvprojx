# Keil uVision project sdcard_frdmk46z.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x1FFFE000,0x8000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: sdcard.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL46Z256VMC4=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, _DEBUG=1
  c misc: -J../../../../../../../../rtos/mqx/config/mcu/MKL46Z4 
-J../../../../../../../../rtos/mqx/config/board/frdmkl46z 
-J../../../../../../../../rtos/mqx/config/common 
-J../../../spi 
-J../../.. 
-J../../../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../../../platform/devices/MKL46Z4/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../source/mfs_sdcard/nio_spi 
-J../../../../../../../../rtos 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../lib/frdmkl46z.mdk/debug/mfs 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/nshell 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/config 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx_stdlib 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/config/mcu/MKL46Z4;../../../../../../../../rtos/mqx/config/board/frdmkl46z;../../../../../../../../rtos/mqx/config/common;../../../spi;../../..;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../source/mfs_sdcard/nio_spi;..\..\..\..\..\source\mfs_sdcard\nio_sdcard;..\..\..\..\..\source\mfs_sdcard\nio_sdcard\sdcard_spi;../../../../../../../../rtos;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../lib/frdmkl46z.mdk/debug/mfs;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/nshell;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/config;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx_stdlib
  asm misc: --cpreproc_opts '-DCPU_MK64FN1M0VMD12=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../../../rtos/mqx/config/mcu/MKL46Z4;../../../../../../../../rtos/mqx/config/board/frdmkl46z;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ../../../../../../../../platform/devices/MKL46Z4/linker/arm/MKL46Z256xxx4_flash.scf
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/KL46Z4/debug/libksdk_platform_mqx.lib 
../../../../../lib/frdmkl46z.mdk/debug/mfs/lib_mfs.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group Config Files
    ../../../../../../../../rtos/mqx/config/mcu/MKL46Z4/: mqx_sdk_config.h
    ../../../../../../../../rtos/mqx/config/board/frdmkl46z/: user_config.h
  group Config Files/Common
    ../../../../../../../../rtos/mqx/config/common/: small_ram_config.h lite_config.h verif_enabled_config.h
  group Sources
    ../../../spi/: sdcard_settings.h
    ../../../: Shell_Task.c Tasks.c
  group BSP Files
    ../../../../../../../../rtos/mqx/mqx/source/include/: mqx.h
    ../../../../../../../../rtos/mqx/mqx/source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/frdmkl46z/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
target int flash release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.6.0
  cpu: as above
  output: sdcard.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MK64FN1M0VMD12=1, FSL_RTOS_MQX=1, PLATFORM_SDK_ENABLED=1, NDEBUG=1
  c misc: -J../../../../../../../../rtos/mqx/config/mcu/MKL46Z4 
-J../../../../../../../../rtos/mqx/config/board/frdmkl46z 
-J../../../../../../../../rtos/mqx/config/common 
-J../../../spi 
-J../../.. 
-J../../../../../../../../rtos/mqx/mqx/source/include 
-J../../../../../../../../rtos/mqx/mqx/source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../../../platform/devices/MKL46Z4/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../source/mfs_sdcard/nio_spi 
-J../../../../../../../../rtos 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../lib/frdmkl46z.mdk/release/mfs 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/nshell 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/config 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx 
-J../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx_stdlib 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../../../rtos/mqx/config/mcu/MKL46Z4;../../../../../../../../rtos/mqx/config/board/frdmkl46z;../../../../../../../../rtos/mqx/config/common;../../../spi;../../..;../../../../../../../../rtos/mqx/mqx/source/include;../../../../../../../../rtos/mqx/mqx/source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../source/mfs_sdcard/nio_spi;../../../../../../../../rtos;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../lib/frdmkl46z.mdk/release/mfs;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/nshell;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/config;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx;../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx_stdlib
  asm misc: --cpreproc_opts '-DCPU_MK64FN1M0VMD12=1,-DFSL_RTOS_MQX=1,-DPLATFORM_SDK_ENABLED=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x1fffe000 size 0x8000
  scatter file: ../../../../../../../../platform/devices/MKL46Z4/linker/arm/MK64FN1M0xxx12_flash.scf
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/KL46Z4/release/libksdk_platform_mqx.lib 
../../../../../lib/frdmkl46z.mdk/release/mfs/lib_mfs.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/nshell/lib_nshell.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx/lib_mqx.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../../../rtos/mqx/lib/frdmkl46z.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
