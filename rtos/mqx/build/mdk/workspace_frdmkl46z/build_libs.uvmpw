<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx_stdlib\build\mdk\mqx_stdlib_frdmkl46z\mqx_stdlib_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\nshell\build\mdk\nshell_frdmkl46z\nshell_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\build\mdk\mqx_frdmkl46z\mqx_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
