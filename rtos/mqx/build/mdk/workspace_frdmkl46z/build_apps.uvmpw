<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">
  <SchemaVersion>1.0</SchemaVersion>
  <Header>### uVision Project, (C) Keil Software</Header>
  <WorkspaceName>WorkSpace</WorkspaceName>
<project><PathAndName>..\..\..\mqx\examples\watchdog_lite\build\mdk\watchdog_lite_frdmkl46z\watchdog_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\watchdog\build\mdk\watchdog_frdmkl46z\watchdog_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\timer\build\mdk\timer_frdmkl46z\timer_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\test\build\mdk\test_frdmkl46z\test_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq_lite\build\mdk\taskq_lite_frdmkl46z\taskq_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskq\build\mdk\taskq_frdmkl46z\taskq_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\taskat\build\mdk\taskat_frdmkl46z\taskat_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem_lite\build\mdk\sem_lite_frdmkl46z\sem_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\sem\build\mdk\sem_frdmkl46z\sem_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill_lite\build\mdk\nill_lite_frdmkl46z\nill_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\nill\build\mdk\nill_frdmkl46z\nill_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex_lite\build\mdk\mutex_lite_frdmkl46z\mutex_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\mutex\build\mdk\mutex_frdmkl46z\mutex_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg_lite\build\mdk\msg_lite_frdmkl46z\msg_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\msg\build\mdk\msg_frdmkl46z\msg_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem_lite\build\mdk\lwsem_lite_frdmkl46z\lwsem_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwsem\build\mdk\lwsem_frdmkl46z\lwsem_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq_lite\build\mdk\lwmsgq_lite_frdmkl46z\lwmsgq_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwmsgq\build\mdk\lwmsgq_frdmkl46z\lwmsgq_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog_lite\build\mdk\lwlog_lite_frdmkl46z\lwlog_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwlog\build\mdk\lwlog_frdmkl46z\lwlog_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent_lite\build\mdk\lwevent_lite_frdmkl46z\lwevent_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwevent\build\mdk\lwevent_frdmkl46z\lwevent_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo_lite\build\mdk\lwdemo_lite_frdmkl46z\lwdemo_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\lwdemo\build\mdk\lwdemo_frdmkl46z\lwdemo_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log_lite\build\mdk\log_lite_frdmkl46z\log_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\log\build\mdk\log_frdmkl46z\log_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog_lite\build\mdk\klog_lite_frdmkl46z\klog_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\klog\build\mdk\klog_frdmkl46z\klog_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr_lite\build\mdk\isr_lite_frdmkl46z\isr_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\isr\build\mdk\isr_frdmkl46z\isr_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello_lite\build\mdk\hello_lite_frdmkl46z\hello_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\hello\build\mdk\hello_frdmkl46z\hello_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event_lite\build\mdk\event_lite_frdmkl46z\event_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\event\build\mdk\event_frdmkl46z\event_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\demo_lite\build\mdk\demo_lite_frdmkl46z\demo_lite_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project><project><PathAndName>..\..\..\mqx\examples\demo\build\mdk\demo_frdmkl46z\demo_frdmkl46z.uvprojx</PathAndName><NodeIsActive>0</NodeIsActive></project></ProjectWorkspace>
