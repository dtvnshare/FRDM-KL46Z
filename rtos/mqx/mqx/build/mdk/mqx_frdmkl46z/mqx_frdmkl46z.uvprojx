# Keil uVision project mqx_frdmkl46z.uvprojx, settings and files
target debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: CPUTYPE("Cortex-M0+")
  output: lib_mqx.lib (library)
  AfterMake: ../../bat/mqx_frdmkl46z.bat ../../../.. ../../../../lib/frdmkl46z.mdk/debug/mqx mdk
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL46Z256VLL4=1, FSL_RTOS_MQX=1, MQX_DISABLE_CONFIG_CHECK=1, _DEBUG=1
  c misc: -J../../../source/psp/cortex_m/compiler/rv_mdk 
-J../../../source/psp/cortex_m 
-J../../../source/psp/cortex_m/cpu 
-J../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../platform/CMSIS/Include 
-J../../../../config/common 
-J../../../../config/mcu/MKL46Z4 
-J../../../../config/board/frdmkl46z 
-J../../../../../../examples/frdmkl46z 
-J../../../../../../platform/devices/MKL46Z4 
-J../../../source/include 
-J../../../source/nio 
-J../../../source/nio/src 
-J../../../source/nio/fs 
-J../../../source/nio/drivers/nio_dummy 
-J../../../source/nio/drivers/nio_mem 
-J../../../source/nio/drivers/nio_null 
-J../../../source/nio/drivers/nio_pipe 
-J../../../source/nio/drivers/nio_serial 
-J../../../source/nio/drivers/nio_tfs 
-J../../../source/nio/drivers/nio_tty 
-J../../../../../../platform/devices/MKL46Z4/startup 
-J../../../source/tad 
-J../../../../mqx_stdlib/source/include 
-J../../../../mqx_stdlib/source/stdio 
-J../../../../../../examples/frdmkl46z 
-J../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../platform/devices/MKL46Z4/include 
-J../../../../../../platform 
-J../../../../../../platform/devices 
-J../../../../../../platform/CMSIS/Include 
-J../../../../../../platform/hal/inc 
-J../../../../../../platform/drivers/inc 
-J../../../../../../platform/drivers/src/mpu 
-J../../../../../../platform/drivers/src/uart 
-J../../../../../../platform/utilities/inc 
-J../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc 
-J../../../../.. 
-J../../../../../../platform/osa/inc 
-J../../../../../../platform/system/inc 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/psp/cortex_m/compiler/rv_mdk;../../../source/psp/cortex_m;../../../source/psp/cortex_m/cpu;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../platform/CMSIS/Include;../../../../config/common;../../../../config/mcu/MKL46Z4;../../../../config/board/frdmkl46z;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4;../../../source/include;../../../source/nio;../../../source/nio/src;../../../source/nio/fs;../../../source/nio/drivers/nio_dummy;../../../source/nio/drivers/nio_mem;../../../source/nio/drivers/nio_null;../../../source/nio/drivers/nio_pipe;../../../source/nio/drivers/nio_serial;../../../source/nio/drivers/nio_tfs;../../../source/nio/drivers/nio_tty;../../../../../../platform/devices/MKL46Z4/startup;../../../source/tad;../../../../mqx_stdlib/source/include;../../../../mqx_stdlib/source/stdio;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../platform/devices/MKL46Z4/include;../../../../../../platform;../../../../../../platform/devices;../../../../../../platform/CMSIS/Include;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/drivers/src/uart;../../../../../../platform/utilities/inc;../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc;../../../../..;../../../../../../platform/osa/inc;../../../../../../platform/system/inc
  asm misc: --cpreproc_opts '-DCPU_MKL46Z256VLL4=1,-DFSL_RTOS_MQX=1,-DMQX_DISABLE_CONFIG_CHECK=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../source/psp/cortex_m/compiler/rv_mdk;../../../source/psp/cortex_m/core/M0;../../../source/psp/cortex_m;../../../../../../platform/devices/MKL46Z4/startup;../../../../config/mcu/MKL46Z4;../../../../config/board/frdmkl46z;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4;../../../source/include;../../../../config/common;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../platform/devices/MKL46Z4/include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl46z.mdk\mqx\intflash.scf
  group KSDK Files
    ../../../../../../platform/devices/MKL46Z4/startup/arm/: startup_MKL46Z4.s
    ../../../../../../platform/devices/MKL46Z4/startup/: system_MKL46Z4.c system_MKL46Z4.h
    ../../../../../../platform/devices/: startup.c
  group MQX Generic/include
    ../../../source/psp/cortex_m/compiler/rv_mdk/: asm_mac.h comp.h comp.c
    ../../../source/include/: gen_rev.h eds.h edserial.h edserprv.h eds_prv.h event.h event_prv.h charq.h klog.h log.h log_prv.h lwsem.h lwevent.h lwevent_prv.h lwlog.h lwlog_prv.h lwmem.h tlsf.h tlsfbits.h tlsf_adaptation.h tlsf_adaptation_prv.h lwmem_prv.h lwmsgq.h lwmsgq_prv.h lwtimer.h lwtimer_prv.h mem_prv.h message.h mmu.h mqx.h mqx_cpudef.h mqx_inc.h mqx_ioc.h mqx_prv.h mqx_str.h mqx_macros.h msg_prv.h mutex.h mutex_prv.h name.h name_prv.h partition.h partition_prv.h pcb.h queue.h sem.h sem_prv.h timer.h timer_prv.h watchdog.h watchdog_prv.h
  group PSP Cortex
    ../../../source/psp/cortex_m/core/M0/: psp_prv.inc boot.S dispatch.S
    ../../../source/psp/cortex_m/: types.inc int_gkis.c int_kisr.c int_pvta.c int_unx.c int_vtab.c int_xcpt.c ipsum.c mem_copy.c mem_zero.c psp_dati.c psp_gelms.c psp_hoti.c psp_iinit.c psp_mat1.c psp_mat2.c psp_mat3.c psp_miti.c psp_msti.c psp_mstiq.c psp_nsti.c psp_psti.c psp_seti.c psp_supp.c psp_tiad.c psp_tida.c psp_tihr.c psp_timn.c psp_tims.c psp_tinm.c psp_tins.c psp_tiol.c psp_tipr.c psp_tips.c psp_tise.c psp_tisu.c psp_tius.c psp_tkti.c psp_usti.c sc_irdyq.c stack_bu.c stack_de.c stack_st.c psp.h psp_abi.h psp_comp.h psp_math.h psp_prv.h psp_rev.h psp_supp.h psp_time.h psptypes.h psp_cpu.h cortex.h kinetis_mpu.h cortex.c nvic.c nvic.h kinetis.h
    ../../../source/psp/cortex_m/cpu/: kinetis_fcan.h
  group CMSIS
    ../../../../../../platform/CMSIS/Include/: core_cm0plus.h core_cmFunc.h core_cmInstr.h
  group Config Files
    ../../../../config/common/: small_ram_config.h lite_config.h verif_enabled_config.h mqx_cnfg.h
    ../../../../config/mcu/MKL46Z4/: mqx_sdk_config.h
    ../../../../config/board/frdmkl46z/: user_config.h
  group MQX Generic/kernel
    ../../../source/kernel/: event.c idletask.c inittask.c int.c lwsem.c mem.c tlsf.c tlsf_adaptation.c mqx.c sched.c task.c time.c taskq.c name.c klog.c log.c lwevent.c lwlog.c lwmem.c lwmsgq.c lwtimer.c msg.c msgq.c msgpool.c mutex.c partition.c queue.c sem.c timer.c watchdog.c
    ../../../source/include/: task.h
  group MQX Generic/nio
    ../../../source/nio/src/: nio.c nio_prv.h errno.c nio_std_adpt.c nio_posix.c
    ../../../source/nio/: nio.h unistd.h ioctl.h fcntl.h
    ../../../source/nio/fs/: fs_supp.c fs_supp.h
  group Peripheral NIO Drivers/nio_dummy
    ../../../source/nio/drivers/nio_dummy/src/: nio_dummy.c
    ../../../source/nio/drivers/nio_dummy/: nio_dummy.h
  group Peripheral NIO Drivers/nio_mem
    ../../../source/nio/drivers/nio_mem/src/: nio_mem.c
    ../../../source/nio/drivers/nio_mem/: nio_mem.h
  group Peripheral NIO Drivers/nio_null
    ../../../source/nio/drivers/nio_null/src/: nio_null.c
    ../../../source/nio/drivers/nio_null/: nio_null.h
  group Peripheral NIO Drivers/nio_pipe
    ../../../source/nio/drivers/nio_pipe/src/: nio_pipe.c
    ../../../source/nio/drivers/nio_pipe/: nio_pipe.h
  group Peripheral NIO Drivers/nio_serial
    ../../../source/nio/drivers/nio_serial/src/: nio_serial.c
    ../../../source/nio/drivers/nio_serial/: nio_serial.h
  group Peripheral NIO Drivers/nio_tfs
    ../../../source/nio/drivers/nio_tfs/src/: nio_tfs.c
    ../../../source/nio/drivers/nio_tfs/: nio_tfs.h
  group Peripheral NIO Drivers/nio_tty
    ../../../source/nio/drivers/nio_tty/src/: nio_tty.c
    ../../../source/nio/drivers/nio_tty/: nio_tty.h
  group MQX Generic/string
    ../../../source/string/: strnlen.c str_utos.c
  group MQX Generic/tad
    ../../../source/tad/: tad.c tad.h
target release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: CPUTYPE("Cortex-M0+")
  output: lib_mqx.lib (library)
  AfterMake: ../../bat/mqx_frdmkl46z.bat ../../../.. ../../../../lib/frdmkl46z.mdk/release/mqx mdk
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKL46Z256VLL4=1, FSL_RTOS_MQX=1, MQX_DISABLE_CONFIG_CHECK=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DCPU_MKL46Z256VLL4=1,-DFSL_RTOS_MQX=1,-DMQX_DISABLE_CONFIG_CHECK=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl46z.mdk\mqx\intflash.scf
