# Keil uVision project demo_frdmkl46z.uvprojx, settings and files
target int flash debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: CPUTYPE("Cortex-M0+")
  output: demo.axf +hex
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL46Z256VLL4=1, FSL_RTOS_MQX=1, _DEBUG=1
  c misc: -J../../../../../../config/mcu/MKL46Z4 
-J../../../../../../config/board/frdmkl46z 
-J../../../../../../config/common 
-J../../.. 
-J../../../../../source/include 
-J../../../../../source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../../../platform/devices/MKL46Z4/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc 
-J../../../../../../.. 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../../lib/frdmkl46z.mdk/debug/config 
-J../../../../../../lib/frdmkl46z.mdk/debug/mqx 
-J../../../../../../lib/frdmkl46z.mdk/debug/mqx_stdlib 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../config/mcu/MKL46Z4;../../../../../../config/board/frdmkl46z;../../../../../../config/common;../../..;../../../../../source/include;../../../../../source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/frdmkl46z;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc;../../../../../../..;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../../lib/frdmkl46z.mdk/debug/config;../../../../../../lib/frdmkl46z.mdk/debug/mqx;../../../../../../lib/frdmkl46z.mdk/debug/mqx_stdlib
  asm misc: --cpreproc_opts '-DCPU_MKL46Z256VLL4=1,-DFSL_RTOS_MQX=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../../../config/mcu/MKL46Z4;../../../../../../config/board/frdmkl46z;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../lib/frdmkl46z.mdk/debug/config;../../../../../../lib/frdmkl46z.mdk/debug/mqx;../../../../../../lib/frdmkl46z.mdk/debug/mqx_stdlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ../../../../../../../../platform/devices/MKL46Z4/linker/arm/MKL46Z256xxx4_flash.scf
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/KL46Z4/debug/libksdk_platform_mqx.lib 
../../../../../../lib/frdmkl46z.mdk/debug/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../lib/frdmkl46z.mdk/debug/mqx/lib_mqx.lib 
../../../../../../lib/frdmkl46z.mdk/debug/mqx/lib_mqx.lib(boot.o) 
../../../../../../lib/frdmkl46z.mdk/debug/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
  group Config Files
    ../../../../../../config/mcu/MKL46Z4/: mqx_sdk_config.h
    ../../../../../../config/board/frdmkl46z/: user_config.h
  group Config Files/Common
    ../../../../../../config/common/: small_ram_config.h lite_config.h verif_enabled_config.h mqx_cnfg.h
  group Sources
    ../../../: ttl.c sender.c semb.c sema.c responde.c mutexb.c mutexa.c main.c eventb.c eventa.c demo.h demo.dsn demo.c btimesli.c atimesli.c
  group BSP Files
    ../../../../../source/include/: mqx.h
    ../../../../../source/bsp/: bsp.h bsp_config.h init_bsp.c mqx_main.c
  group Debug Console
    ../../../../../../../../platform/utilities/src/: fsl_misc_utilities.c fsl_debug_console.c print_scan.h print_scan.c
    ../../../../../../../../platform/utilities/inc/: fsl_debug_console.h
  group KSDK Files
    ../../../../../../../../examples/frdmkl46z/: board.h board.c gpio_pins.h gpio_pins.c pin_mux.h pin_mux.c
target int flash release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: CPUTYPE("Cortex-M0+")
  output: demo.axf +hex
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKL46Z256VLL4=1, FSL_RTOS_MQX=1, NDEBUG=1
  c misc: -J../../../../../../config/mcu/MKL46Z4 
-J../../../../../../config/board/frdmkl46z 
-J../../../../../../config/common 
-J../../.. 
-J../../../../../source/include 
-J../../../../../source/bsp 
-J../../../../../../../../platform/utilities 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../examples/frdmkl46z 
-J../../../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../../../platform/devices/MKL46Z4/include 
-J../../../../../../../../platform 
-J../../../../../../../../platform/devices 
-J../../../../../../../../platform/CMSIS/Include 
-J../../../../../../../../platform/hal/inc 
-J../../../../../../../../platform/drivers/inc 
-J../../../../../../../../platform/drivers/src/mpu 
-J../../../../../../../../platform/drivers/src/uart 
-J../../../../../../../../platform/utilities/inc 
-J../../../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc 
-J../../../../../../.. 
-J../../../../../../../../platform/osa/inc 
-J../../../../../../../../platform/system/inc 
-J../../../../../../lib/frdmkl46z.mdk/release/config 
-J../../../../../../lib/frdmkl46z.mdk/release/mqx 
-J../../../../../../lib/frdmkl46z.mdk/release/mqx_stdlib 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../../../../config/mcu/MKL46Z4;../../../../../../config/board/frdmkl46z;../../../../../../config/common;../../..;../../../../../source/include;../../../../../source/bsp;../../../../../../../../platform/utilities;../../../../../../../../examples/frdmkl46z;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../../../platform;../../../../../../../../platform/devices;../../../../../../../../platform/CMSIS/Include;../../../../../../../../platform/hal/inc;../../../../../../../../platform/drivers/inc;../../../../../../../../platform/drivers/src/mpu;../../../../../../../../platform/drivers/src/uart;../../../../../../../../platform/utilities/inc;../../../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc;../../../../../../..;../../../../../../../../platform/osa/inc;../../../../../../../../platform/system/inc;../../../../../../lib/frdmkl46z.mdk/release/config;../../../../../../lib/frdmkl46z.mdk/release/mqx;../../../../../../lib/frdmkl46z.mdk/release/mqx_stdlib
  asm misc: --cpreproc_opts '-DCPU_MKL46Z256VLL4=1,-DFSL_RTOS_MQX=1,-DNDEBUG=1' --cpreproc
  asm include: ../../../../../../config/mcu/MKL46Z4;../../../../../../config/board/frdmkl46z;../../../../../../../../examples/frdmkl46z;../../../../../../../../platform/devices/MKL46Z4/startup;../../../../../../../../platform/devices/MKL46Z4/include;../../../../../../lib/frdmkl46z.mdk/release/config;../../../../../../lib/frdmkl46z.mdk/release/mqx;../../../../../../lib/frdmkl46z.mdk/release/mqx_stdlib
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: as above
  link misc: ../../../../../../../../lib/ksdk_mqx_lib/mdk/KL46Z4/release/libksdk_platform_mqx.lib 
../../../../../../lib/frdmkl46z.mdk/release/mqx_stdlib/lib_mqx_stdlib.lib 
../../../../../../lib/frdmkl46z.mdk/release/mqx/lib_mqx.lib 
../../../../../../lib/frdmkl46z.mdk/release/mqx/lib_mqx.lib(boot.o) 
../../../../../../lib/frdmkl46z.mdk/release/mqx/lib_mqx.lib(startup_*.o) 
--remove 
--autoat 
--any_placement=first_fit 
--predefine="-D__stack_size__=0x400" 
--predefine="-D__heap_size__=0x200"
