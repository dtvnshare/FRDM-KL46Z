# Keil uVision project nshell_frdmkl46z.uvprojx, settings and files
target debug (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: CPUTYPE("Cortex-M0+")
  output: lib_nshell.lib (library)
  AfterMake: ../../bat/nshell_frdmkl46z.bat ../../../.. ../../../../lib/frdmkl46z.mdk/debug/nshell mdk
  c flags: Optim=1 OneElfS=1
  c define: CPU_MKL46Z256VLL4=1, FSL_RTOS_MQX=1, _DEBUG=1
  c misc: -J../../../source/include 
-J../../../source/include 
-J../../../../mqx/source/psp/cortex_m/compiler/rv_mdk 
-J../../../../mqx/source/psp/cortex_m 
-J../../../../mqx/source/psp/cortex_m/cpu 
-J../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../platform/CMSIS/Include 
-J../../../../config/common 
-J../../../../config/mcu/MKL46Z4 
-J../../../../config/board/frdmkl46z 
-J../../../../../../examples/frdmkl46z 
-J../../../../../../platform/devices/MKL46Z4 
-J../../../../mqx/source/include 
-J../../../../mqx/source/nio 
-J../../../../mqx/source/nio/src 
-J../../../../mqx/source/nio/fs 
-J../../../../mqx/source/nio/drivers/nio_dummy 
-J../../../../mqx/source/nio/drivers/nio_mem 
-J../../../../mqx/source/nio/drivers/nio_null 
-J../../../../mqx/source/nio/drivers/nio_pipe 
-J../../../../mqx/source/nio/drivers/nio_serial 
-J../../../../mqx/source/nio/drivers/nio_tfs 
-J../../../../mqx/source/nio/drivers/nio_tty 
-J../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../mqx/source/tad 
-J../../../../mqx_stdlib/source/include 
-J../../../../mqx_stdlib/source/stdio 
-J../../../../../../examples/frdmkl46z 
-J../../../../../../platform/devices/MKL46Z4/startup 
-J../../../../../../platform/devices/MKL46Z4/include 
-J../../../../../../platform 
-J../../../../../../platform/devices 
-J../../../../../../platform/CMSIS/Include 
-J../../../../../../platform/hal/inc 
-J../../../../../../platform/drivers/inc 
-J../../../../../../platform/drivers/src/mpu 
-J../../../../../../platform/drivers/src/uart 
-J../../../../../../platform/utilities/inc 
-J../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc 
-J../../../../.. 
-J../../../../../../platform/osa/inc 
-J../../../../../../platform/system/inc 
-J#J 
--library_interface=none 
--c99 
--diag_suppress=1296,186
  c include: ../../../source/include;../../../source/include;../../../../mqx/source/psp/cortex_m/compiler/rv_mdk;../../../../mqx/source/psp/cortex_m;../../../../mqx/source/psp/cortex_m/cpu;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../platform/CMSIS/Include;../../../../config/common;../../../../config/mcu/MKL46Z4;../../../../config/board/frdmkl46z;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4;../../../../mqx/source/include;../../../../mqx/source/nio;../../../../mqx/source/nio/src;../../../../mqx/source/nio/fs;../../../../mqx/source/nio/drivers/nio_dummy;../../../../mqx/source/nio/drivers/nio_mem;../../../../mqx/source/nio/drivers/nio_null;../../../../mqx/source/nio/drivers/nio_pipe;../../../../mqx/source/nio/drivers/nio_serial;../../../../mqx/source/nio/drivers/nio_tfs;../../../../mqx/source/nio/drivers/nio_tty;../../../../../../platform/devices/MKL46Z4/startup;../../../../mqx/source/tad;../../../../mqx_stdlib/source/include;../../../../mqx_stdlib/source/stdio;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../platform/devices/MKL46Z4/include;../../../../../../platform;../../../../../../platform/devices;../../../../../../platform/CMSIS/Include;../../../../../../platform/hal/inc;../../../../../../platform/drivers/inc;../../../../../../platform/drivers/src/mpu;../../../../../../platform/drivers/src/uart;../../../../../../platform/utilities/inc;../../../../../../middleware/filesystem/mfs/source/mfs_sdcard/nio_esdhc;../../../../..;../../../../../../platform/osa/inc;../../../../../../platform/system/inc
  asm misc: --cpreproc_opts '-DCPU_MKL46Z256VLL4=1,-DFSL_RTOS_MQX=1,-D_DEBUG=1' --cpreproc
  asm include: ../../../../mqx/source/psp/cortex_m/compiler/rv_mdk;../../../../mqx/source/psp/cortex_m/core/M0;../../../../mqx/source/psp/cortex_m;../../../../../../platform/devices/MKL46Z4/startup;../../../../config/mcu/MKL46Z4;../../../../config/board/frdmkl46z;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4;../../../../mqx/source/include;../../../../config/common;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../examples/frdmkl46z;../../../../../../platform/devices/MKL46Z4/startup;../../../../../../platform/devices/MKL46Z4/include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl46z.mdk\mqx\intflash.scf
  group Shell Source/mqx
    ../../../source/mqx/: sh_abort.c sh_kill.c sh_pause.c sh_tad.c
    ../../../source/include/: sh_prv.h shell.h
  group Shell Source/shell
    ../../../source/shell/: sh_cmdlist.c sh_exit.c sh_help.c sh_sh.c sh_util.c shell.c
    ../../../source/include/: sh_rtcs.h sh_enet.h
target release (ARM-ADS)
  device: MKL46Z256xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.2.2
  cpu: CPUTYPE("Cortex-M0+")
  output: lib_nshell.lib (library)
  AfterMake: ../../bat/nshell_frdmkl46z.bat ../../../.. ../../../../lib/frdmkl46z.mdk/release/nshell mdk
  c flags: Optim=4 OneElfS=1
  c define: CPU_MKL46Z256VLL4=1, FSL_RTOS_MQX=1, NDEBUG=1
  c misc: as above
  c include: as above
  asm misc: --cpreproc_opts '-DCPU_MKL46Z256VLL4=1,-DFSL_RTOS_MQX=1,-DNDEBUG=1' --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x6000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: ..\..\..\lib\frdmkl46z.mdk\mqx\intflash.scf
